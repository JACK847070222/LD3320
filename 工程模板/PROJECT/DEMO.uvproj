# Keil uVision project DEMO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DEMO +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\Systick;..\HARDWARE\USART;..\HARDWARE\CS5532;..\HARDWARE\KEY;..\HARDWARE\SPI;..\HARDWARE\LD3320
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Systick/: SysTick.C
    ../HARDWARE/USART/: Usart.c
    ../HARDWARE/KEY/: KEY.C
    ../HARDWARE/SPI/: SPI.C
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CORE/: core_cm3.c
  group STARTUP
    ../CORE/: startup_stm32f10x_hd.s
  group LD3320
    ../HARDWARE/LD3320/: LD3320.c
